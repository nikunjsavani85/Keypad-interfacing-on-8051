# Keil uVision project keypad_interfacing_with_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: keypad_interfacing_with_8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup File
    ./: STARTUP.A51
  group Main File
    ./: keypad_interfacing.c
  group Header File
    ./: delay.h keypad4x4.h lcd8bit.h
